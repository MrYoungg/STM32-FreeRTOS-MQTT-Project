# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf --text -a -c --output=debug.dis Objects\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Library;.\FreeRTOS;.\FreeRTOS\include;.\Hardware;.\MQTT\common;.\MQTT\mqtt;.\MQTT\mqttclient;.\MQTT\platform\FreeRTOS;.\MQTT\network;.\MQTT\network\mbedtls\include;.\LwIP\src\include;.\LwIP\contrib\ports\freertos\include;.\ATCommand;.\RingBuffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Hardware
    ./Hardware/: OLED.c OLED_Data.c Delay.c Key.c AT_USART.c Debug_USART.c
  group FreeRTOS
    ./FreeRTOS/: heap_4.c list.c port.c queue.c tasks.c event_groups.c
    ./FreeRTOS/include/: FreeRTOSConfig.h FreeRTOS.h
  group ATCommand
    ./ATCommand/: ATCommand.c
  group RingBuffer
    ./RingBuffer/: RingBuffer.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h mqtt_config.h
  group MQTT
    ./MQTT/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group LwIP/src/api
    ./LwIP/src/api/: sockets.c netdb.c err.c tcpip.c netbuf.c api_lib.c api_msg.c if_api.c netifapi.c
  group LwIP/src/core
    ./LwIP/src/core/: def.c altcp.c altcp_alloc.c altcp_tcp.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group LwIP/src/core/ipv4
    ./LwIP/src/core/ipv4/: ip4_addr.c acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_frag.c
  group LwIP/arch
    ./LwIP/contrib/ports/freertos/: sys_arch.c
  group LwIP/src/netif
    ./LwIP/src/netif/: ethernet.c
